<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pwr_rtc_deeppwd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


