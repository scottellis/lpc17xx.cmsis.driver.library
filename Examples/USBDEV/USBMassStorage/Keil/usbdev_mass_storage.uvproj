# Keil uVision project usbdev_mass_storage.uvproj, settings and files
target LPC1700 RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbdev_mass_storage +hex
  c flags: Optim=1 wLevel=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=1,__PACK__
  c include: ..\..\..\..\Drivers\include;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group System
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Source
    ../: usbcore.c usbdesc.c usbhw.c usbuser.c mscuser.c memory.c
    ../../../../Drivers/source/: lpc17xx_nvic.c
  group Disk Image
    ../: DiskImg.c
  group Readme
    ../: Abstract.txt
target LPC1700 FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: usbdev_mass_storage +hex
  c flags: Optim=1 wLevel=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0,__PACK__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
