<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ssp_sc16is750_poll.ewp</path>
  </project>
  <batchBuild/>
</workspace>


