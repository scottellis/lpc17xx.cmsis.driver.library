<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2c_sc16is750_int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


