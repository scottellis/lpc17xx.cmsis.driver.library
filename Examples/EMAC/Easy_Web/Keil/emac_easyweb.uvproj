# Keil uVision project emac_easyweb.uvproj, settings and files
target LPC1700 FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: emac_easyweb +hex
  c flags: Optim=1 wLevel=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0
  c include: ..\..\..\..\Core\CM3\CoreSupport;..\..\..\..\Drivers\include;..\..\Easy_Web;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group Driver Files
    ../../../../Drivers/source/: lpc17xx_uart.c lpc17xx_clkpwr.c lpc17xx_emac.c lpc17xx_nvic.c lpc17xx_pinsel.c debug_frmwrk.c
  group Main
    ../: easyweb.c tcpip.c EMAC.c ADC.c Retarget.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
