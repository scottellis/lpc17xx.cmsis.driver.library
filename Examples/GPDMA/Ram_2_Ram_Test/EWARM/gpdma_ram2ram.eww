<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gpdma_ram2ram.ewp</path>
  </project>
  <batchBuild/>
</workspace>


