<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gpdma_linklist.ewp</path>
  </project>
  <batchBuild/>
</workspace>


