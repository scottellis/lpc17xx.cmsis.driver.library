<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uart1_modem.ewp</path>
  </project>
  <batchBuild/>
</workspace>


